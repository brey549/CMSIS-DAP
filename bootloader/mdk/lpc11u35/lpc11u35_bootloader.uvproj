# Keil uVision project lpc11u35_bootloader.uvproj, settings and files
target lpc11u35_bootloader (ARM-ADS)
  device: LPC11U35/501 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: lpc11u35_bootloader
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\BIN\ElfDwT.exe #L
  AfterMake: fromelf --bin -o "@L.bin" "#L"
  c flags: Optim=3
  c define: __RTX, TARGET_LPC11U35, BOARD_LPC812_MAX
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_NXP\TARGET_LPC11UXX;..\..\..\shared\rtos
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  scatter file: ..\..\..\shared\cmsis\TARGET_NXP\TARGET_LPC11UXX\TOOLCHAIN_ARM_STD\LPC11U35_bootloader.sct
  group CMSIS
    ../../../shared/cmsis/TARGET_NXP/TARGET_LPC11UXX/TOOLCHAIN_ARM_STD/: startup_LPC11Uxx.s
    ../../../shared/cmsis/TARGET_NXP/TARGET_LPC11UXX/: system_LPC11Uxx.c
  group Common
    ../../Common/src/: flash_svc.c main.c RTX_Config.c SVC_Table.s usb_config.c usbd_user_msc.c version.c
  group HAL
    ../../hal/TARGET_NXP/TARGET_LPC11U35/: gpio.c read_uid.c usbd_LPC11Uxx.c vector_table.c flash_hal.c
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_core.c usbd_core_msc.c usbd_msc.c
  group RTX
    ../../../shared/rtos/: HAL_CM1.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
